# Keil uVision project DISCO-F746NG_TicTacToe.uvprojx, settings and files
target DISCO-F746NG_TicTacToe (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NG STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: CPUTYPE("Cortex-M7") FPU2
  output: DISCO-F746NG_TicTacToe
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_STM32F746 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_RTC=1 --split_sections -DFEATURE_LWIP=1 -DTARGET_STM32F7 -D__ASSERT_MSG -DTARGET_RELEASE --md --no_rtti -DMBED_BUILD_TIMESTAMP=1492848116.01 -DDEVICE_PORTINOUT=1 -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DARM_MATH_CM7 --cpu=Cortex-M7.fp.sp -DTARGET_STM32F746NG -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DTARGET_LIKE_CORTEX_M7 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -DTARGET_DISCO_F746NG -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DTARGET_STM32F746xG -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -D__CORTEX_M7 -DTARGET_M7 -DDEVICE_SERIAL=1 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM
  c include: .; BSP_DISCO_F746NG; BSP_DISCO_F746NG/Drivers; BSP_DISCO_F746NG/Drivers/BSP; BSP_DISCO_F746NG/Drivers/BSP/Components; BSP_DISCO_F746NG/Drivers/BSP/Components/Common; BSP_DISCO_F746NG/Drivers/BSP/Components/ft5336; BSP_DISCO_F746NG/Drivers/BSP/Components/n25q128a; BSP_DISCO_F746NG/Drivers/BSP/Components/ov9655; BSP_DISCO_F746NG/Drivers/BSP/Components/rk043fn48h; BSP_DISCO_F746NG/Drivers/BSP/Components/wm8994; BSP_DISCO_F746NG/Drivers/BSP/STM32746G-Discovery; BSP_DISCO_F746NG/Utilities; BSP_DISCO_F746NG/Utilities/Fonts; LCD_DISCO_F746NG; TS_DISCO_F746NG; mbed/.; mbed/TARGET_DISCO_F746NG; mbed/TARGET_DISCO_F746NG/TARGET_STM; mbed/TARGET_DISCO_F746NG/TARGET_STM/TARGET_STM32F7; mbed/TARGET_DISCO_F746NG/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG; mbed/TARGET_DISCO_F746NG/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/TARGET_DISCO_F746NG; mbed/TARGET_DISCO_F746NG/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/device; mbed/TARGET_DISCO_F746NG/TARGET_STM/TARGET_STM32F7/device; mbed/TARGET_DISCO_F746NG/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M7,-DARM_MATH_CM7,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_DISCO_F746NG/TOOLCHAIN_ARM_STD/stm32f746xg.sct
  group BSP_DISCO_F746NG
    BSP_DISCO_F746NG/Drivers/BSP/Components/Common/: accelero.h audio.h camera.h epd.h gyro.h idd.h io.h lcd.h magneto.h ts.h tsensor.h
    BSP_DISCO_F746NG/Utilities/Fonts/: font12.c font16.c font20.c font24.c font8.c fonts.h
    BSP_DISCO_F746NG/Drivers/BSP/Components/ft5336/: ft5336.c ft5336.h
    BSP_DISCO_F746NG/Drivers/BSP/Components/n25q128a/: n25q128a.h
    BSP_DISCO_F746NG/Drivers/BSP/Components/ov9655/: ov9655.c ov9655.h
    BSP_DISCO_F746NG/Drivers/BSP/Components/rk043fn48h/: rk043fn48h.h
    BSP_DISCO_F746NG/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery.h stm32746g_discovery_audio.c stm32746g_discovery_audio.h stm32746g_discovery_camera.c stm32746g_discovery_camera.h stm32746g_discovery_eeprom.c stm32746g_discovery_eeprom.h stm32746g_discovery_lcd.c stm32746g_discovery_lcd.h stm32746g_discovery_qspi.c stm32746g_discovery_qspi.h stm32746g_discovery_sd.c stm32746g_discovery_sd.h stm32746g_discovery_sdram.c stm32746g_discovery_sdram.h stm32746g_discovery_ts.c stm32746g_discovery_ts.h
    BSP_DISCO_F746NG/Drivers/BSP/Components/wm8994/: wm8994.c wm8994.h
  group DISCO-F746NG_TicTacToe
    ./: main.cpp mbed_config.h
  group LCD_DISCO_F746NG
    LCD_DISCO_F746NG/: LCD_DISCO_F746NG.cpp LCD_DISCO_F746NG.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_DISCO_F746NG/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32f746xg.o stm32f7xx_hal.o stm32f7xx_hal_adc.o stm32f7xx_hal_adc_ex.o stm32f7xx_hal_can.o stm32f7xx_hal_cec.o stm32f7xx_hal_cortex.o stm32f7xx_hal_crc.o stm32f7xx_hal_crc_ex.o stm32f7xx_hal_cryp.o stm32f7xx_hal_cryp_ex.o stm32f7xx_hal_dac.o stm32f7xx_hal_dac_ex.o stm32f7xx_hal_dcmi.o stm32f7xx_hal_dcmi_ex.o stm32f7xx_hal_dfsdm.o stm32f7xx_hal_dma.o stm32f7xx_hal_dma2d.o stm32f7xx_hal_dma_ex.o stm32f7xx_hal_dsi.o stm32f7xx_hal_eth.o stm32f7xx_hal_flash.o stm32f7xx_hal_flash_ex.o stm32f7xx_hal_gpio.o stm32f7xx_hal_hash.o stm32f7xx_hal_hash_ex.o stm32f7xx_hal_hcd.o stm32f7xx_hal_i2c.o stm32f7xx_hal_i2c_ex.o stm32f7xx_hal_i2s.o stm32f7xx_hal_irda.o stm32f7xx_hal_iwdg.o stm32f7xx_hal_jpeg.o stm32f7xx_hal_lptim.o stm32f7xx_hal_ltdc.o stm32f7xx_hal_ltdc_ex.o stm32f7xx_hal_mdios.o stm32f7xx_hal_mmc.o stm32f7xx_hal_nand.o stm32f7xx_hal_nor.o stm32f7xx_hal_pcd.o stm32f7xx_hal_pcd_ex.o stm32f7xx_hal_pwr.o stm32f7xx_hal_pwr_ex.o stm32f7xx_hal_qspi.o stm32f7xx_hal_rcc.o stm32f7xx_hal_rcc_ex.o stm32f7xx_hal_rng.o stm32f7xx_hal_rtc.o stm32f7xx_hal_rtc_ex.o stm32f7xx_hal_sai.o stm32f7xx_hal_sai_ex.o stm32f7xx_hal_sd.o stm32f7xx_hal_sdram.o stm32f7xx_hal_smartcard.o stm32f7xx_hal_smartcard_ex.o stm32f7xx_hal_smbus.o stm32f7xx_hal_spdifrx.o stm32f7xx_hal_spi.o stm32f7xx_hal_sram.o stm32f7xx_hal_tim.o stm32f7xx_hal_tim_ex.o stm32f7xx_hal_uart.o stm32f7xx_hal_usart.o stm32f7xx_hal_wwdg.o stm32f7xx_ll_adc.o stm32f7xx_ll_crc.o stm32f7xx_ll_dac.o stm32f7xx_ll_dma.o stm32f7xx_ll_dma2d.o stm32f7xx_ll_exti.o stm32f7xx_ll_fmc.o stm32f7xx_ll_gpio.o stm32f7xx_ll_i2c.o stm32f7xx_ll_lptim.o stm32f7xx_ll_pwr.o stm32f7xx_ll_rcc.o stm32f7xx_ll_rng.o stm32f7xx_ll_rtc.o stm32f7xx_ll_sdmmc.o stm32f7xx_ll_spi.o stm32f7xx_ll_tim.o stm32f7xx_ll_usart.o stm32f7xx_ll_usb.o stm32f7xx_ll_utils.o stm_spi_api.o sys.o system_stm32f7xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    mbed/TARGET_DISCO_F746NG/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_DISCO_F746NG/TARGET_STM/TARGET_STM32F7/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h
    mbed/TARGET_DISCO_F746NG/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f746xx.h stm32f7xx.h system_stm32f7xx.h
    mbed/TARGET_DISCO_F746NG/TARGET_STM/: gpio_object.h mbed_rtx.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h
    mbed/: mbed.h
    mbed/TARGET_DISCO_F746NG/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/: objects.h
    mbed/TARGET_DISCO_F746NG/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/TARGET_DISCO_F746NG/: PeripheralNames.h PinNames.h
    mbed/TARGET_DISCO_F746NG/TARGET_STM/TARGET_STM32F7/device/: stm32_hal_legacy.h stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_conf.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.h stm32f7xx_hal_mmc.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_smbus.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_adc.h stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_crc.h stm32f7xx_ll_dac.h stm32f7xx_ll_dma.h stm32f7xx_ll_dma2d.h stm32f7xx_ll_exti.h stm32f7xx_ll_fmc.h stm32f7xx_ll_gpio.h stm32f7xx_ll_i2c.h stm32f7xx_ll_iwdg.h stm32f7xx_ll_lptim.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_rng.h stm32f7xx_ll_rtc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_spi.h stm32f7xx_ll_system.h stm32f7xx_ll_tim.h stm32f7xx_ll_usart.h stm32f7xx_ll_usb.h stm32f7xx_ll_utils.h stm32f7xx_ll_wwdg.h
  group TS_DISCO_F746NG
    TS_DISCO_F746NG/: TS_DISCO_F746NG.cpp TS_DISCO_F746NG.h
